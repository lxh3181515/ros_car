# Keil uVision project Nano_Controller.uvprojx, settings and files
target Nano_Controller (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Nano_Controller +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,MPU9250,EMPL_TARGET_STM32F4,EMPL
  c include: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ..\Middlewares\DMP\driver\eMPL; ..\Middlewares\DMP\driver\include; ..\Middlewares\DMP\driver\stm32L; ..\Middlewares\DMP\eMPL-hal; ..\Middlewares\DMP\mllite; ..\Middlewares\DMP\mpl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/User
    ../Src/: mainloop.c main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../Inc/: mainloop.h
  group BSP
    ../Src/BSP/: bsp_motor.c bsp_encoder.c bsp_servo.c mpu9250.c simi2c.c bsp_exti.c
    ../Inc/BSP/: bsp_motor.h bsp_encoder.h bsp_servo.h mpu9250.h simi2c.h
  group APP
    ../Inc/APP/: Config.h Battery.h Communication.h IMU.h Indicate.h Kinematics.h LogModule.h Motor.h PS2.h Servo.h
    ../Src/APP/: Battery.c Communication.c IMU.c Indicate.c Kinematics.c LogModule.c Motor.c PS2.c Servo.c
  group Middlewares/DMP_Library
    ../Middlewares/DMP/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Middlewares/DMP/driver/stm32L/: log_stm32.c
    ../Middlewares/DMP/eMPL-hal/: eMPL_outputs.c
    ../Middlewares/DMP/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../Middlewares/DMP/mpl/: libmpllib.lib
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ./: startup_stm32f103xe.s
    ../Src/: system_stm32f1xx.c
software components: CMSIS:CORE 5.3.0
